require cwe798-embedded-auth.inc
IOTBENCH_EMBEDDED_AUTH_VARIANT = "shell"
