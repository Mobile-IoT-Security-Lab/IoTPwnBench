require java-command-fixture.inc
SUMMARY = "IoTBench fixture - CWE-78 Java OS command injection"
JAVA_COMMAND_VARIANT = "os"
JAVA_COMMAND_MAIN = "FixtureOsCommand"
