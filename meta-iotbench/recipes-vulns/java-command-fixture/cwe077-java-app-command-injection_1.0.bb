require java-command-fixture.inc
SUMMARY = "IoTBench fixture - CWE-77 Java application command injection"
JAVA_COMMAND_VARIANT = "app"
JAVA_COMMAND_MAIN = "FixtureAppCommand"
