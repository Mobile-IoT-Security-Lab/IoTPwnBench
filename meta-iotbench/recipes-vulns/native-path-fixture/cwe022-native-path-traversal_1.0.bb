PATH_FIXTURE_CWE = "022"
require native-path-fixture.inc
