PATH_FIXTURE_CWE = "020"
require native-path-fixture.inc
