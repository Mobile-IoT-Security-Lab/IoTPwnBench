require cwe798-password-leak.inc
IOTBENCH_PASSWORD_LEAK_VARIANT = "init-password"
