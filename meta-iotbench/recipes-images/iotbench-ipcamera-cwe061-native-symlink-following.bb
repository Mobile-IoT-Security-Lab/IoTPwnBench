# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/ipcamera/device-ipcamera.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - ipcamera, native symlink following (CWE-61)"
