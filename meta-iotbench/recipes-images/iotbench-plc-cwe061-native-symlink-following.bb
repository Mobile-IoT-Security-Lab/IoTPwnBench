# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/plc/device-plc.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - plc, native symlink following (CWE-61)"
