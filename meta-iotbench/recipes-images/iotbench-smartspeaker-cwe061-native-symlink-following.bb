# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/smartspeaker/device-smartspeaker.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - smartspeaker, native symlink following (CWE-61)"
