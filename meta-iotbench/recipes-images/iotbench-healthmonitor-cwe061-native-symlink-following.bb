# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/healthmonitor/device-healthmonitor.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - healthmonitor, native symlink following (CWE-61)"
