# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/router/device-router.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - router, native symlink following (CWE-61)"
