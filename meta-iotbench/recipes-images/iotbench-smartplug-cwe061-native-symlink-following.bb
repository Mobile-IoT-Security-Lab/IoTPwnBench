# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/smartplug/device-smartplug.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - smartplug, native symlink following (CWE-61)"
