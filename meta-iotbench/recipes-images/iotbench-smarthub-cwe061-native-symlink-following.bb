# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/smarthub/device-smarthub.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - smarthub, native symlink following (CWE-61)"
