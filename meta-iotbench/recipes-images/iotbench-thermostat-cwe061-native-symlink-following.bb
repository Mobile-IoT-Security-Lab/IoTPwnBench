# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/thermostat/device-thermostat.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - thermostat, native symlink following (CWE-61)"
