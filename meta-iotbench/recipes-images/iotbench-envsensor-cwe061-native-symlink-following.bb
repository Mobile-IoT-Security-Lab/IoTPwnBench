# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/envsensor/device-envsensor.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - envsensor, native symlink following (CWE-61)"
