# INTENTIONALLY INSECURE SYNTHETIC TEST FIXTURE - NOT FOR DEPLOYMENT
require recipes-images/iotbench-image.inc
require recipes-devices/smartbulb/device-smartbulb.inc
require recipes-images/iotbench-native-symlink-fixture.inc

SUMMARY = "IoTBench target - smartbulb, native symlink following (CWE-61)"
