# Correct the pinned upstream layer's SPDX-style separator for BitBake's parser.
LICENSE = "Apache-2.0 & BSD-2-Clause"
